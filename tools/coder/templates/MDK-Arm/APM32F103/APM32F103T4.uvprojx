# Keil uVision project APM32F103T4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: APM32F103T4 Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32F103T4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
