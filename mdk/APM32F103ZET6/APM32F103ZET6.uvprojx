# Keil uVision project APM32F103ZET6.uvprojx, settings and files
target APM32F103ZET6 (6180000::V6.18::ARMCLANG)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32F103ZET6
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c include: ..\..\csp\inc;..\..\drivers\csp_hal\inc;..\..\drivers\csp_rt\inc;..\..\libraries\APM32F10x_StdPeriphDriver\inc;..\..\libraries\CMSIS\Device\Geehy\APM32F10x\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group applications
    ../../applications/: main.c
  group drivers/csp_hal
    ../../drivers/csp_hal/src/: chal_clock.c chal_flash.c chal_gpio.c chal_hal.c
  group drivers/csp_rt
    ../../drivers/csp_rt/src/: components.c
  group libraries/CMSIS
    ../../libraries/CMSIS/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
    ../../libraries/CMSIS/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s
  group libraries/APM32F10x_StdPeriphDriver
    ../../libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_emmc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
software components: CMSIS:CORE 5.6.0
